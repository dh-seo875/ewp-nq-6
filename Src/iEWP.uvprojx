# Keil uVision project iEWP.uvprojx, settings and files
target iEWP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TLE9877QXW40 Infineon
  pack: Infineon.TLE987x_DFP.1.6.2
  cpu: IRAM(0x18000000,0x1800) IROM(0x11000000,0xEFFC) IROM2(0x1100EFFC,4) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: iEWP +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\emo;.\lin_driver;.\app;.\driver;.\CMSIS;.\mhLib;.\mhLib\Bsw;.\mhLib\Rte;.\mhLib\Swc;.\uds
  memory RVCT4: ROM 0x11000000 size 0xeffc
  memory RVCT5: ROM 0x1100effc size 0x4
  memory RVCT9: RAM 0x18000018 size 0x13e8
  memory RVCT10: RAM 0x18001400 size 0x14
  scatter file: .\Objects\iEWP.sct
  group app
    ./app/: Main.c linmain.c
    ./mhLib/: remapVector.c
  group emo
    ./emo/: Emo.c Emo_cfg.c Emo_RAM.c Emo_speed_api.c Table.c
  group lin
    ./lin_driver/: genLinConfig.c lin_driver_api.c lin_hal.c lin_main.c lin_slave_task.c lin_config.c lin_diag_raw.c lin_diag_tp.c lin_master_task.c
  group Driver
    ./driver/: adc1.c adc2.c bdrv.c bootrom.c ccu6.c csa.c gpt12e.c int.c isr.c lin.c mon.c port.c scu.c system_tle987x.c timer2x.c tle_device.c uart.c wdt1.c startup_tle987x.s pmu.c
  group SwC
    ./mhLib/Swc/: Sensor.c Sensor_cfg.c Diag.c Diag_cfg.c Sensor_IIR.c Manage.c Manage_cfg.c
  group Bsw
    ./mhLib/Bsw/: scheduler.c Temperature.c CommManager.c CommRouter.c DiagManager.c DiagServiceProcess.c ExampleCode.c Nvm.c
  group Rte
    ./mhLib/Rte/: RteApp.c RteHal.c RteStd.c
  group Uds
    ./uds/: uds.c util.c
